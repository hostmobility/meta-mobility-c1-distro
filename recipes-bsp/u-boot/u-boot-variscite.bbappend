FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0005-Add-autoboot-key-configuration.patch"
