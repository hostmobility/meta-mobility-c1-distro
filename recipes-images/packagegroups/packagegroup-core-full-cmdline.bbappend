# Drop mc's perl extfs helpers to keep perl out of the image
RDEPENDS:packagegroup-core-full-cmdline-utils:remove = "mc-helpers-perl"
